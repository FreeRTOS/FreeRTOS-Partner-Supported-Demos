# Keil uVision project FreeRTOS_Demo.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: FT32F072R8ATx FMD
  pack: FMD.FT32F0xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\User\Include;..\..\Source\include;.\User\Driver\inc;.\User\Libraries\FT32F0xx_Driver\Inc;.\User\Tasks\inc;.\User\Template;.\User\Libraries\CMSIS\FT32F0xx\Include;..\Common\include;..\..\Source\portable\GCC\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ./User/: main.c main-standardtest.c main-demo.c ft32f0xx_it.c
    ./User/Libraries/CMSIS/FT32F0xx/source/arm/: startup_ft32f072xb.s
  group Driver
    ./User/Driver/src/: board.c Peripheral.c
  group FreeRTOS
    ../../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/GCC/ARM_CM0/: port.c
  group Libraris
    ./User/Libraries/FT32F0xx_Driver/Src/: ft32f0xx_adc.c ft32f0xx_comp.c ft32f0xx_crc.c ft32f0xx_crs.c ft32f0xx_dac.c ft32f0xx_debug.c ft32f0xx_dma.c ft32f0xx_exti.c ft32f0xx_flash.c ft32f0xx_gpio.c ft32f0xx_i2c.c ft32f0xx_iwdg.c ft32f0xx_misc.c ft32f0xx_opa.c ft32f0xx_pwr.c ft32f0xx_rcc.c ft32f0xx_rtc.c ft32f0xx_spi.c ft32f0xx_syscfg.c ft32f0xx_tim.c ft32f0xx_usart.c ft32f0xx_wwdg.c
    ./User/Libraries/CMSIS/FT32F0xx/source/: system_ft32f0xx.c
  group Template
    ./User/Template/: IntQueueTimer.c RegTests.c TestRunner.c
  group Common
    ../Common/Minimal/: AbortDelay.c BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c integer.c IntQueue.c IntSemTest.c MessageBufferAMP.c MessageBufferDemo.c PollQ.c QPeek.c QueueOverwrite.c QueueSet.c QueueSetPolling.c recmutex.c semtest.c StaticAllocation.c StreamBufferDemo.c StreamBufferInterrupt.c TaskNotify.c TaskNotifyArray.c TimerDemo.c
  group Tasks
    ./User/Tasks/src/: HighProTask.c IdleTask.c InitTask.c LowProTask.c TaskManager.c
